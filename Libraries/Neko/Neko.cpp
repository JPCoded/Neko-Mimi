#include "Arduino.h"
#include "Neko.h"
#include "Servo.h"

Neko::Neko(int pin, int pin2, int pin3, int pin4)
{
	_servos[0].attach(pin);		//BaseRight
	_servos[1].attach(pin2);	//TopRight
	_servos[2].attach(pin3);	//BaseLeft
	_servos[3].attach(pin4);	//TopLeft
}

void Neko::setNTB(int NTB[][4])
{
	for(int i = 0; i < 3; i++)
	{
		for(int j = 0; j < 4; j++)
		{
			_NTB[i][j] = NTB[i][j];
		}
	}
}

void Neko::move(int cat)
{
	for(int i = 0; i < 4; i++)
	{
		_servos[i].write(_NTB[cat][i]);
	}
}




